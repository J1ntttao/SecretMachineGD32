# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407_EC12 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYS_SUPPORT_OS
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Library;..\Library\I2C;..\Library\SPI;..\App;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\Hardware;..\Hardware\OLED;..\Third_Party\u8g2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: App.h App_Keys.c App_GameProcess.c App_OLED.c App_WS2812.c App_LevelConfig.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Hardware
    ../Hardware/: bsp_keys.c bsp_keys.h driver_ws2812b.c driver_ws2812b.h
    ../Hardware/OLED/: oled.c oled.h oledfont.h bmp.h
  group Library
    ../Library/: USART0.c EXTI.c TIMER.c Delay.h Delay.c
    ../Library/I2C/: I2C.c I2C0.c I2C2.c I2C1.h I2C1.c
    ../Library/SPI/: SPI.c SPI1.c SPI0.c
  group Library/configs
    ../Library/: EXTI_config.h TIMER_config.h
    ../Library/I2C/: I2C_config.h
    ../Library/SPI/: SPI_config.h
  group ThirdParty
    ../Third_Party/u8g2/: mui.c mui.h mui_u8g2.c mui_u8g2.h u8g2.h u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8.h u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_i2c.c gd32f4xx_adc.c gd32f4xx_spi.c
  group Doc
    ../Doc/: readme.txt
  group FreeRTOS/Core
    ../FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS
    ../FreeRTOS/include/: FreeRTOSConfig.h
